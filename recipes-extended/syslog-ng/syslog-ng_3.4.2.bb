#
# Copyright (C) 2013 Wind River Systems, Inc.
#
require syslog-ng.inc
PR = "${INC_PR}.0"

LICENSE = "GPLv2 & LGPLv2.1"

LIC_FILES_CHKSUM = "file://COPYING;md5=e0e8658d9be248f01b7933df24dc1408"

SRC_URI[md5sum] = "2e32c5fedc067dd83a363c0316b29fb4"
SRC_URI[sha256sum] = "f2585b42e7341bc53490aa59c5f405df506536bf0672bf71f9567ea78590f381"
