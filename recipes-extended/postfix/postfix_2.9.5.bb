require postfix.inc

SRC_URI[postfix-2.9.5.md5sum] = "588e1c54588e6da0c4b3436f1c2c2fb3"
SRC_URI[postfix-2.9.5.sha256sum] = "590381cc0705a6d3fd2279760e79aff625adab6000cb895cf5336ae6a11ee6e4"

PR = "${INC_PR}.0"
