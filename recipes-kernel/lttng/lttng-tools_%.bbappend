#
# Copyright (C) 2014 Wind River Systems, Inc.
#
# LOCAL REV: WR specific configure
#
PACKAGECONFIG_append = " python"
