#
# Copyright (C) 2015 Wind River Systems, Inc.
#

FILESEXTRAPATHS_prepend := "${THISDIR}/crash:"
SRC_URI += "file://support-GRSecurity-in-x86.patch"
