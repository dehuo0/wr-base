# LOCAL REV: WR specific image.
# 
PR = "r500"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES = "file://psplash-default-img.h"
